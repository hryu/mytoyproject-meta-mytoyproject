IMAGE_INSTALL_aarch64 = " \
    packagegroup-core-boot \
    qemu \
    libvirt \
    libvirt-libvirtd \
    libvirt-virsh \
    "
