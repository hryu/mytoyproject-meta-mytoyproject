SRC_URI[md5sum] = "e623ae1598bb75f101345e6c15320478"

SRC_URI = "git://kernel.googlesource.com/pub/scm/linux/kernel/git/firmware/linux-firmware;protocol=https;"
